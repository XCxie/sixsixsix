# Keil uVision project UCOSII-1.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: UCOSII-1 +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\timer;..\SYSTEM\usart;..\SYSTEM\iwdg;..\STM32F10x_FWLib\inc;..\CORE;..\UCOSII\CONFIG;..\UCOSII\CORE;..\UCOSII\PORT;..\HARDWARE\GPIO;..\HARDWARE\OLED;..\HARDWARE\SPI;..\HARDWARE\FLASH;..\HARDWARE\ADC;..\SYSTEM\exti;..\SYSTEM\RTC;..\HARDWARE\USB;..\USER;..\HARDWARE\CRC16
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c system_stm32f10x.c stm32f10x_it.c TASK.c Hydraulic_control.c Hydraulic_process.c Data_process.c
  group HARDWARE
    ../HARDWARE/GPIO/: gpio.c
    ../HARDWARE/OLED/: him_user_driver.c him_user_process.c hmi_user_uart.c
    ./: USBType-C.c Driver_usart.c Driver_user_driver.c
    ../HARDWARE/FLASH/: MX25L6406.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/USB/: CH374DRV.C CH374HFM.LIB
    ../HARDWARE/CRC16/: CRC16.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/timer/: timer.c
    ../SYSTEM/iwdg/: iwdg.c
    ../SYSTEM/exti/: exti.c
    ../SYSTEM/RTC/: rtc.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_spi.c stm32f10x_dma.c stm32f10x_adc.c stm32f10x_iwdg.c stm32f10x_exti.c stm32f10x_rtc.c stm32f10x_bkp.c stm32f10x_pwr.c
  group UCOSII-CORE
    ../UCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group UCOSII-PORT
    ../UCOSII/PORT/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group UCOSII-CONFIG
    ../UCOSII/CONFIG/: includes.h os_cfg.h
software components: CMSIS:CORE 4.1.0
